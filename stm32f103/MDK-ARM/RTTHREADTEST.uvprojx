# Keil uVision project RTTHREADTEST.uvprojx, settings and files
target RTTHREADTEST (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTTHREADTEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/RT-Thread//include/; ../Middlewares/Third_Party/RT-Thread//components/drivers/include/; ../Middlewares/Third_Party/RT-Thread//components/drivers/include/drivers/; ../Middlewares/Third_Party/RT-Thread//components/drivers/include/ipc/; ../Middlewares/Third_Party/RT-Thread//bsp/; ../Middlewares/Third_Party/RT-Thread//components/finsh/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c app_rtthread.c stm32f1xx_it.c stm32f1xx_hal_msp.c drv_usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/RT-Thread/RTOS/device drivers
    ../Middlewares/Third_Party/RT-Thread/components/drivers/serial/: serial.c
    ../Middlewares/Third_Party/RT-Thread/components/drivers/src/: completion.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RT-Thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
software components: CMSIS:CORE 4.3.0
